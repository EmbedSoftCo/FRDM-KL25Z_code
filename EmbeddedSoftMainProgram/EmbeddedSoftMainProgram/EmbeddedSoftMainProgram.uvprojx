# Keil uVision project EmbeddedSoftMainProgram.uvprojx, settings and files
target EmbeddedSoftMainProgram (6210000::V6.21::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TimersLab
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: CLOCK_SETUP=1
  c misc: -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion -Wno-declaration-after-statement -Wno-unused-function -Wno-unsafe-buffer-usage
  c include: .\rg;.\pit;.\queue;.\tpm1;.\uart0;.\EEPROM;.\delay;.\i2c0;.\bme280;.\i2c1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group pit
    ./pit/: pit.c pit.h
  group queue
    ./queue/: queue.c queue.h
  group src
    ./src/: main.c
  group tpm1
    ./tpm1/: tpm1.c tpm1.h
  group uart0
    ./uart0/: uart0.c uart0.h
  group EEPROM
    ./EEPROM/: EEPROM.c EEPROM.h
  group delay
    ./delay/: delay.c delay.h
  group rg
    ./rg/: rg.c rg.h
  group i2c0
    ./i2c0/: i2c0.h i2c0.c
  group bme280
    ./bme280/: bme280.c bme280.h
  group i2c1
    ./i2c1/: i2c1.c i2c1.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.5.0
