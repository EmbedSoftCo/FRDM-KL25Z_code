# Keil uVision project SerialLab.uvprojx, settings and files
target Serial Lab (6210000::V6.21::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SerialLab
  c flags: Optim=4 v6Lang=5 v6LangP=8 wLevel=2
  c define: CLOCK_SETUP=1
  c misc: -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion -Wno-declaration-after-statement -Wno-unsafe-buffer-usage
  c include: .\queue;.\rgb;.\uart0; .\uart2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group queue
    ./queue/: queue.c queue.h
  group rgb
    ./rgb/: rgb.c rgb.h
  group src
    ./src/: main.c
  group uart0
    ./uart0/: uart0.c uart0.h
  group uart2
    ./uart2/: uart2.c uart2.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.5.0
